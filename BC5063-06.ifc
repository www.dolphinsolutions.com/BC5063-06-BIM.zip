Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2023-06-12T11:21:48
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.11200.0000 - Exporter 18.0.0.412 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jun 12 11:21:48 2023 * Host: ANDYHOUSE * Database: C:\Users\ANDYHO~1.DOL\AppData\Local\Temp\{A866217F-362D-405C-81BC-9DDA6C21525A}\ifc * Database version: 5507 * Database creation date: Mon Jun 12 11:21:46 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jun 12 11:21:47 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jun 12 11:21:47 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: Standard, Family1:Standard:201818
In: Level 1
Type - Material: Default
Type - Dimensions - FFL_Offset: 680 mm; XY_Offset: 0 mm; YZ_Offset: 0 mm
Type - Identity Data - Description: SupportRailDropDownGrabRail; Manufacturer: DolphinSolutionsLimited; Model: BC5063-06; OmniClass Number: 23.40.00.00; OmniClass Title: Equipment and Furnishings; Type Name: Standard; URL: https://www.dolphinsolutions.co.uk/product/dolphin-friction-hinged-drop-down-rail-concealed-fixings/
Type - Model Properties - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_84:SupportRails; CodePerformance: n/a; Color: BrushedSatin_Available in Ceramic or Powder coated RAL colours; Constituents: n/a; DurationUnit: year; ExpectedLife: n/a; Features: Friction Hinged; Finish: Brushed Satin_PowderCoated_or_CeramicCoated; Grade: 304; ManufacturerName: DOLPHIN FRICTION HINGED DROP DOWN RAIL – CONCEALED FIXINGS; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC5063-06; ModelReference: DOLPHIN FRICTION HINGED DROP DOWN RAIL – CONCEALED FIXINGS; NBSDescription: SupportRails; NominalHeight: 143; NominalLength: 800; NominalWidth: 103; Part Number: BC5063-06; Uniclass2015Code: Pr_40_20_76_84; Uniclass2015Title: Support Rails; WarrantyDurationUnit: year
Type - Other - Category: Specialty Equipment; Family Name: Family1
Pset_BuildingElementProxyCommon - Reference: Standard
Pset_ManufacturerTypeInformation - ModelReference: DOLPHIN FRICTION HINGED DROP DOWN RAIL – CONCEALED FIXINGS; Manufacturer: DolphinSolutionsLimited
Constraints - Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.0184495 m2; Volume: 0.000612863 m3
Other - Family: Family1: Standard; Family and Type: Family1: Standard; Type: Family1: Standard; Type Id: Family1: Standard
Phasing - Phase Created: New Construction
